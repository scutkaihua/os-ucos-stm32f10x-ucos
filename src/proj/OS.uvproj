# Keil uVision project OS.uvproj, settings and files
target app (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OS +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\app;..\outlib;..\app\inc;..\ucos\core;..\ucos\config;..\ucos\cpu;..\ucos\port;..\ucos\lib;..\app\app
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: main.c t_mutex.c ucos-main.c Stm32F10x_Std.lib stm32f10x_it.c startup_stm32f10x_hd.s system_stm32f10x.c
    ../app/app/: app.c
  group outlib
    ../outlib/: gtOsStm32F10x.lib
  group util
    ../util/: gtOs.h sys_call_list.c sys_call_RTX.c
  group os.bat
    ./: os4xx.bat os10x.bat
  group ucos/core
    ../ucos/core/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group ucos/config
    ../ucos/config/: os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group ucos/cpu
    ../ucos/cpu/: cpu_c.c cpu_core.c cpu_a.asm
  group ucos/port
    ../ucos/port/: os_cpu_c.c os_cpu_a.asm
  group ucos/lib
    ../ucos/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
target stm32f4xxlib (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: gtosStm32F4xx (library)
  AfterMake: ".\os4xx.bat"
  c flags: Optim=1
  c include: ..\config;..\cpu;..\lib\CM;..\lib;..\util;..\cpu\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target stm32f10xlib (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: gtOsStm32F10x (library)
  AfterMake: ".\os10x.bat"
  c flags: Optim=4 OneElfS=1
  c include: ..\util;..\ucos\core;..\ucos\config;..\ucos\cpu;..\ucos\port;..\ucos\lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
